## boards/wiznet/w55rp20_evb_pico/board.yml
```yaml
board:
  name: w55rp20_evb_pico
  full_name: W55RP20 Evaluation Pico
  vendor: wiznet
  socs:
  - name: rp2040
```
